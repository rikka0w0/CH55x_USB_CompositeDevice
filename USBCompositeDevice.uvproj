# Keil uVision project USBCompositeDevice.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: USBCompositeDevice +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: CLOCK_FREQ_24
  group Source Group 1
    ./: usb_hid_desc.c usb_ep0.c usb_desc.c usb_it.c usb_endp.c usb_string_desc.c usb_bot.c usb_scsi.c scsi_data.c usb_mal.c i2c.c eeprom.c ch554_conf.c Delay.C main.c usb_hid_keyboard.c
